# Keil uVision project SafeBoot_App.uvprojx, settings and files
target App_v10 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SafeBoot_App_v10 +hex
  AfterMake: fromelf --bin --output=.\Objects\SafeBoot_App_v10.bin .\Objects\SafeBoot_App_v10.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,APP_VARIANT=10
  c misc: --no-multibyte-chars
  c include: .\Start;..\common;..\bsp;..\middleware;..\app
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s system_stm32f10x.c core_cm3.c
  group common
    ../common/: crc16.c crc32.c
  group bsp
    ../bsp/: bsp.c bsp_flash.c
  group middleware
    ../middleware/: boot_meta.c iap_proto.c
  group app
    ../app/: app_main.c
target App_v11 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: SafeBoot_App_v11 +hex
  AfterMake: fromelf --bin --output=.\Objects\SafeBoot_App_v11.bin .\Objects\SafeBoot_App_v11.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,APP_VARIANT=11
  c misc: --no-multibyte-chars
  c include: .\Start;..\common;..\bsp;..\middleware;..\app
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x5000
target App_v12_Bad (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: SafeBoot_App_v12_bad +hex
  AfterMake: fromelf --bin --output=.\Objects\SafeBoot_App_v12_bad.bin .\Objects\SafeBoot_App_v12_bad.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,APP_VARIANT=99
  c misc: --no-multibyte-chars
  c include: .\Start;..\common;..\bsp;..\middleware;..\app
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x5000

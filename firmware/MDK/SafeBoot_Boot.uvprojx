# Keil uVision project SafeBoot_Boot.uvprojx, settings and files
target SafeBoot_Boot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SafeBoot_Boot +hex
  AfterMake: fromelf --bin --output=.\Objects\SafeBoot_Boot.bin .\Objects\SafeBoot_Boot.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c misc: --no-multibyte-chars
  c include: .\Start;..\common;..\bsp;..\middleware;..\boot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s system_stm32f10x.c core_cm3.c
  group common
    ../common/: crc16.c crc32.c
  group bsp
    ../bsp/: bsp.c bsp_flash.c
  group middleware
    ../middleware/: boot_meta.c iap_proto.c
  group boot
    ../boot/: boot_jump.c boot_main.c
